FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://faulty-frag.cfg;md5=8cae207dec0f0df8f3d9feb02d55a602"